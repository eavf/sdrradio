options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: down_rate
  id: variable
  parameters:
    value: 250e3
  states: {}
- name: rfgain
  id: variable_qtgui_range
  parameters:
    gui_hint: tab
    label: RF Gain
    start: '10'
    step: '12'
    stop: '70'
    value: '15'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: stat_chooser
  id: variable_qtgui_chooser
  parameters:
    gui_hint: tab@0
    label: Station Chooser
    labels: '["NoName", "Nostalgie","RC Brussels","La Premiere","Fun Radio", "NRJ","Armada Russe"]'
    num_opts: '0'
    options: '[89.45e6,100e6, 92.1e6, 96.1e6, 104.7e6, 103.7e6, 21.438e3]'
    type: real
    value: 89.45e6
  states: {}
- name: volume_slider
  id: variable_qtgui_range
  parameters:
    gui_hint: tab@1
    label: Volume
    start: '0'
    step: '1'
    stop: '100'
    value: '25'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: down_rate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '24000'
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: volume_slider/100
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    beta: '6.76'
    cutoff_freq: 100e3
    decim: int(samp_rate/down_rate)
    gain: '2'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3
    win: window.WIN_KAISER
  states: {}
- name: note_0
  id: note
  parameters:
    note: Fungujuce Radio
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: down_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@1
    name: '"Demod out"'
    type: float
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: stat_chooser
    fftsize: '1024'
    gui_hint: tab@0
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '250'
    interp: '24'
    type: fff
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    center_freq: stat_chooser
    gain: rfgain
    samp_rate: samp_rate
    type: fc32
    vga: '20'
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    label0: tuner
    label1: audio
    num_tabs: '2'
  states: {}

connections:
- [analog_wfm_rcv_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_1, '0', audio_sink_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_1, '0']
- [soapy_hackrf_source_0, '0', low_pass_filter_0, '0']
- [soapy_hackrf_source_0, '0', qtgui_freq_sink_x_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
