options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: tab@0
    label: Chanel
    start: 88.1e6
    step: '100'
    stop: 107.9e6
    value: 100e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: tab@1
    label: Volume
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0.5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: volume_slider
  id: variable_qtgui_range
  parameters:
    gui_hint: tab@2
    label: Volume
    start: '0'
    step: '1'
    stop: '10'
    value: '5'
  states: {}
- name: analog_fm_deemph_0
  id: analog_fm_deemph
  parameters:
    samp_rate: 48e3
    tau: '75e-6'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: 240e3
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: volume_slider
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: '10'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 5e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 15e3
    decim: '5'
    gain: '0.5'
    samp_rate: 240e3
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: 240e3
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@1
    name: '"Baseband Spectrum"'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: 48e3
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@2
    name: '"Audio Spectrum"'
    type: float
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    gui_hint: tab@0
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '100'
    interp: '12'
    type: ccc
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    center_freq: freq
    gain: '20'
    samp_rate: samp_rate
    type: fc32
    vga: '20'
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    label0: Tuner
    label1: Baseband
    label2: Audio
    num_tabs: '3'
  states: {}

connections:
- [analog_fm_deemph_0, '0', blocks_multiply_const_vxx_1, '0']
- [analog_fm_deemph_0, '0', qtgui_freq_sink_x_0_0, '0']
- [analog_wfm_rcv_0, '0', low_pass_filter_0_0, '0']
- [analog_wfm_rcv_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_1, '0', audio_sink_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [low_pass_filter_0_0, '0', analog_fm_deemph_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']
- [soapy_hackrf_source_0, '0', low_pass_filter_0, '0']
- [soapy_hackrf_source_0, '0', qtgui_freq_sink_x_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
