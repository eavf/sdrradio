options:
  parameters:
    author: vovo
    generate_options: qt_gui
    id: vectorinput
    output_language: python
    title: Vector input
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: vectorLenght
  id: variable
  parameters:
    value: '16'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vectorLenght
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: vectorLenght
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, vectorSize=16):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Max Hold Block',
                  in_sig=[(np.float32,vectorSize)],
                  out_sig=[(np.float32,vectorSize)]
              )


          def work(self, input_items, output_items):
              """The work() function is modified to include the max hold function."""
              # Add a loop over all of the vectors in input_items[0]:
              for vectorIndex in range(len(input_items[0])):
              	# Calculate the max value of the vector:
              	maxValue = np.max(input_items[0][vectorIndex])
              	# Loop over each of the input samples:
              	for sampleIndex in range(len(input_items[0][vectorIndex])):
              		# Assign each output sample maxValue:
              		output_items[0][vectorIndex][sampleIndex] = maxValue
              return len(output_items[0])
    vectorSize: vectorLenght
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: sinusoid
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: sinusoid
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [analog_sig_source_x_0, '0', virtual_sink_0, '0']
- [blocks_stream_to_vector_0, '0', epy_block_0, '0']
- [blocks_throttle_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_time_sink_x_0, '0']
- [epy_block_0, '0', blocks_vector_to_stream_0, '0']
- [virtual_source_0, '0', qtgui_time_sink_x_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
