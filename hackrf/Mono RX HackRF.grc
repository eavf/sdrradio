options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: down_rate
  id: variable
  parameters:
    value: 250e3
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: tab@0
    label: Chanel
    start: 88.1e6
    step: '100'
    stop: 107.9e6
    value: 100e6
    widget: slider
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: tab@1
    label: gain
    start: '10'
    step: '12'
    stop: '70'
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: stat_chooser
  id: variable_qtgui_chooser
  parameters:
    gui_hint: tab@0
    label: Station Chooser
    labels: '["NoName", "Nostalgie","RC Brussels","La Premiere","Fun Radio", "NRJ"]'
    num_opts: '0'
    options: '[89.45e6,100e6, 92.1e6, 96.1e6, 104.7e6, 103.7e6]'
    type: real
    value: 89.45e6
  states: {}
- name: volume_slider
  id: variable_qtgui_range
  parameters:
    gui_hint: tab@2
    label: Volume
    start: '0'
    step: '1'
    stop: '10'
    value: '2'
  states: {}
- name: analog_fm_deemph_0
  id: analog_fm_deemph
  parameters:
    samp_rate: 48e3
    tau: '75e-6'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: down_rate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: volume_slider
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    beta: '6.76'
    cutoff_freq: 100e3
    decim: '8'
    gain: '2'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3
    win: window.WIN_KAISER
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    beta: '6.76'
    cutoff_freq: 15e3
    decim: '25'
    gain: '48'
    samp_rate: down_rate
    type: fir_filter_fff
    width: '100'
    win: window.WIN_KAISER
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: down_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@1
    name: '"Baseband Spectrum"'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: 48e3
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@2
    name: '"Audio Spectrum"'
    type: float
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    gui_hint: tab@0
    type: complex
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    center_freq: stat_chooser
    gain: gain
    samp_rate: samp_rate
    type: fc32
    vga: '20'
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    label0: Tuner
    label1: Baseband
    label2: Audio
    num_tabs: '3'
  states: {}

connections:
- [analog_fm_deemph_0, '0', blocks_multiply_const_vxx_1, '0']
- [analog_fm_deemph_0, '0', qtgui_freq_sink_x_0_0, '0']
- [analog_wfm_rcv_0, '0', low_pass_filter_0_0, '0']
- [analog_wfm_rcv_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_1, '0', audio_sink_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_0_0, '0', analog_fm_deemph_0, '0']
- [soapy_hackrf_source_0, '0', low_pass_filter_0, '0']
- [soapy_hackrf_source_0, '0', qtgui_freq_sink_x_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
