options:
  parameters:
    generate_options: qt_gui
    id: RadioSpectrumAnalyser
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF Gain
    start: '0'
    step: '1'
    stop: '76'
    value: '50'
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    label: Sample Rate
    start: '192000'
    step: '1000'
    stop: '20000000'
    value: '1000000'
  states: {}
- name: tuning
  id: variable_qtgui_range
  parameters:
    label: Frequency
    start: '70000000'
    step: '200000'
    stop: '6000000000'
    value: '102100000'
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    ant0: TX/RX
    bb_gain0: '20'
    bw0: samp_rate
    freq0: tuning
    gain0: rf_gain
    if_gain0: '20'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {state: disabled}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    ant0: TX/RX
    bb_gain0: '20'
    bw0: samp_rate
    freq0: tuning
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: tuning
    fftsize: '1024'
    name: '"Spectrum Analyser"'
    showports: 'True'
    showrf: 'True'
    type: complex
  states: {}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    bandwidth: samp_rate
    center_freq: tuning
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    bandwidth: samp_rate
    center_freq: tuning
    gain: rf_gain
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: samp_rate
    center_freq0: tuning
    gain0: rf_gain
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [osmosdr_source_0, '0', osmosdr_sink_0, '0']
- [qtgui_sink_x_0, freq, uhd_usrp_source_0, command]
- [soapy_hackrf_source_0, '0', soapy_hackrf_sink_0, '0']
- [uhd_usrp_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
