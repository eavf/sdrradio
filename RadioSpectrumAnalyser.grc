options:
  parameters:
    generate_options: qt_gui
    id: RadioSpectrumAnalyser
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF Gain
    start: '0'
    step: '1'
    stop: '76'
    value: '50'
  states: {}
- name: rf_gain_0
  id: variable_qtgui_range
  parameters:
    label: RF Gain
    start: '0'
    step: '1'
    stop: '76'
    value: '50'
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    label: Sample Rate
    start: 1e6
    step: 1e6
    stop: 20e6
    value: 1e6
  states: {}
- name: tuning
  id: variable_qtgui_range
  parameters:
    label: Frequency
    start: '70000000'
    step: '200000'
    stop: '6000000000'
    value: '102100000'
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: tuning
    fftsize: '1024'
    name: '"Spectrum Analyser"'
    showports: 'True'
    showrf: 'True'
    type: complex
  states: {}
- name: soapy_hackrf_source_1
  id: soapy_hackrf_source
  parameters:
    bandwidth: samp_rate
    center_freq: tuning
    dev_args: hackrf=0
    gain: rf_gain
    samp_rate: samp_rate
    type: fc32
    vga: rf_gain_0
  states: {}

connections:
- [qtgui_sink_x_0_0, freq, soapy_hackrf_source_1, cmd]
- [soapy_hackrf_source_1, '0', qtgui_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
